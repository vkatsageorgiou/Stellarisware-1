# IAR project usb_host_keyboard.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3Sx7xx Luminary LM3Sx7xx
  ICCARM.CCDefines: ewarm; PART_LM3S3748; TARGET_IS_DUSTDEVIL_RA0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..; ..\..\..
  OBJCOPY.OOCOutputFile: usb_host_keyboard.bin
  ILINK.IlinkOutputFile: usb_host_keyboard.out
  ILINK.IlinkIcfFile: usb_host_keyboard.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../driverlib/ewarm/Exe/: driverlib.a
    ../../../grlib/ewarm/Exe/: grlib.a
    ../../../usblib/ewarm/Exe/: usblib.a
  group Source
    ../drivers/: formike128x128x16.c
    ./: startup_ewarm.c usb_host_keyboard.c
    ../../../utils/: uartstdio.c
