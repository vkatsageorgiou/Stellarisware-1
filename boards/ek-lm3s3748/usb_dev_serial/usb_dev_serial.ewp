# IAR project usb_dev_serial.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3Sx7xx Luminary LM3Sx7xx
  ICCARM.CCDefines: ewarm; PART_LM3S3748; UART_BUFFERED; TARGET_IS_DUSTDEVIL_RA0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..; ..\..\..
  OBJCOPY.OOCOutputFile: usb_dev_serial.bin
  ILINK.IlinkOutputFile: usb_dev_serial.out
  ILINK.IlinkIcfFile: usb_dev_serial.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../driverlib/ewarm/Exe/: driverlib.a
    ../../../grlib/ewarm/Exe/: grlib.a
    ../../../usblib/ewarm/Exe/: usblib.a
  group Source
    ../drivers/: formike128x128x16.c
    ./: startup_ewarm.c usb_dev_serial.c usb_serial_structs.c
    ../../../utils/: uartstdio.c ustdlib.c
